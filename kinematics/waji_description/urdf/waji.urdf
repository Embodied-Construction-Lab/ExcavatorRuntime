Commit message: fix: 修复真机观测同步与动作执行超时

File: kinematics/waji_description/urdf/waji.urdf (robot description, URDF)
Before this commit: robot waji, 7 links, 6 joints
Joints:
- joint bucket_joint: origin xyz=0.35 0 0 rpy=0 2.74 0 -> xyz=0.35 0 0 rpy=0 3.67 0
